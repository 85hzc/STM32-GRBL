# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\lib;.\sys;.\user;.\user\exti;.\user\tim;.\user\adc;.\user\pwm;.\user\spi&iic;.\user\mpu6050;.\user\kalman;.\user\dac;.\user\screen;.\user\ov7670;.\user\sdcard;.\user\bmp;.\user\cnc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./lib/: STM32_lib_3.0.lib
  group sys
    ./sys/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group user
    ./user/: main.c stm32f10x_it.c stm32f10x_conf.h gpio.c usart.c delay.c eeprom.c
  group tim
    ./user/tim/: tim.c
  group pwm
    ./user/pwm/: pwm.c
  group cnc
    ./user/cnc/: coolant_control.c gcode.c limits.c motion_control.c nuts_bolts.c planner.c print.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c pin_map.h eepromavr.c
